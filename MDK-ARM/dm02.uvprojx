# Keil uVision project dm02.uvprojx, settings and files
target dm02 (6070000::V6.7::.\ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: dm02 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_PRESENT=1U,ARM_MATH_CHECK
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Control;../Control/Algorithms;../Control/Algorithms/math_support;../Control/Algorithms/mahony;../Control/Gait;../Control/Kinematics;../Application;../Application/Robot;../Platform/Bsp/CAN;../Platform/Drivers/motor_lz;../System/Runtime;../System/Runtime/task;../Platform/Drivers/remote_control;../Platform/Drivers/bmi088;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: ..\dm02.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c bdma.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c arm_lib_stubs.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Control/Algorithms
    ../Control/Algorithms/: crc_ccitt.h struct_typedef.h
    ../Control/Algorithms/math_support/: math_support.cpp math_support.h
    ../Control/Algorithms/mahony/: mahony_filter.c mahony_filter.h
  group Application/Control
    ../Control/: robot_config.h
    ../Control/Kinematics/: fivebar.cpp fivebar.h
    ../Control/Gait/: simple_gait.cpp simple_gait.h
    ../Application/Robot/: robot_application.cpp robot_application.h
    ../Application/: robot_app.cpp robot_app.h
  group Platform/Bsp
    ../Platform/Bsp/Can/: bsp_fdcan.cpp bsp_fdcan.h
  group Platform/Drivers
    ../Platform/Drivers/remote_control/: remote_control.cpp remote_control.h
    ../Platform/Drivers/bmi088/: bmi088_driver.c bmi088_driver.h bmi088_platform.c bmi088_platform.h
  group Platform/Drivers/motor_lz
    ../Platform/Drivers/motor_lz/: motor_LZ.cpp motor_LZ.h
  group System/Runtime
    ../System/Runtime/task/: motor_task.cpp motor_task.h control_task.cpp control_task.h imu_task.c imu_task.h system_timer_task.cpp system_timer_task.h
    ../System/Runtime/: robot_io.cpp robot_io.h
  group DSP
    ../Middlewares/ST/ARM/Lib/: arm_cortexM7lfdp_math.lib
software components: CMSIS:CORE 6.1.0
